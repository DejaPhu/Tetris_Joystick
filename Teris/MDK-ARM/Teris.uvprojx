# Keil uVision project Teris.uvprojx, settings and files
target Teris (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Teris +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../../bsp/inc;../../hal/vendor/STM32F1xx_HAL_Driver/Inc;../../hal/vendor/STM32F1xx_HAL_Driver/Inc/Legacy;../../middlewares/FreeRTOS/Source/include;../../middlewares/FreeRTOS/Source/CMSIS_RTOS_V2;../../middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../middlewares/CMSIS/Device/ST/STM32F1xx/Include;../../middlewares/CMSIS/Include;../../app/inc;../../hal/inc
  asm include: as above
  memory RVCT1: ROM 0x08000000 size 0x10000
  memory RVCT4: ROM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group BSP/Generated
    ../../bsp/src/: freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../hal/vendor/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../../bsp/src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../../middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../middlewares/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/Tasks and Engine
    ../../app/src/: app_diagnostics.c button_filter.c joystick_filter.c game_engine.c game_fsm.c task_display.c task_game.c task_input.c ui_renderer.c app_log.c
  group Application/Main
    ../../: main.c
  group HAL/Board peripherals
    ../../hal/src/: hal_buzzer.c hal_oled.c hal_gpio.c hal_joystick.c hal_uart.c
software components: CMSIS:CORE 4.3.0
